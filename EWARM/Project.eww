<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F103C8T6_DIGI_USB.ewp</path>
  </project>
  <batchBuild />
</workspace>
